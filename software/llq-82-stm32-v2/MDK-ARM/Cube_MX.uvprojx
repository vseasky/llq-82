# Keil uVision project Cube_MX.uvprojx, settings and files
target Cube_MX (6160000::V6.16::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Cube_MX +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F405xx,STM32_THREAD_SAFE_STRATEGY
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Drivers/CMSIS/Include;      ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;      ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;      ..\groundwork;      ..\groundwork\keyboard;      ..\applications;      ..\groundwork\bsp_adc;      ..\groundwork\bsp_flash;      ..\groundwork\bsp_hx04_hid_km;      ..\groundwork\bsp_delay;      ..\groundwork\ws2812b;      ..\groundwork\bsp_lcd;      ..\LVGL8;      ..\LVGL8\lvgl;      ..\LVGL8\lvgl_drive;      ..\LVGL8\lvgl_app;      ..\groundwork\bsp_touch;      ..\groundwork\bsp_usart;      ..\groundwork\bsp_password;      ..\algorithm\CRC_Protocol;      ..\groundwork\bsp_sw6208;      ..\groundwork\bsp_ble;      ..\groundwork\bsp_gui
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./: startup_stm32f405xx.s
    ../Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group algorithm
    ../algorithm/CRC_Protocol/: bsp_crc16.c
  group applications
    ../applications/: keyboard_task.c key_task.c ws2812b_task.c flash_task.c touch_task.c power_task.c
  group groundwork
    ../groundwork/bsp_flash/: bsp_flash.c
    ../groundwork/bsp_adc/: bsp_adc.c
    ../groundwork/bsp_delay/: bsp_delay.c
    ../groundwork/ws2812b/: bsp_ws2812b.c
    ../groundwork/bsp_touch/: bsp_bm2166.c
    ../groundwork/bsp_usart/: bsp_usart.c
    ../groundwork/bsp_password/: bsp_password.c
    ../groundwork/bsp_sw6208/: bsp_sw6208.c
    ../groundwork/keyboard/: bsp_key.c
    ../groundwork/: bsp_interface.c
    ../groundwork/bsp_ble/: bsp_ble.c
  group lvgl/app
    ../LVGL8/lvgl_app/: lvgl_task.c lvgl_app.c
    ../groundwork/bsp_gui/: bsp_gui.c
  group lcd
    ../groundwork/bsp_lcd/: lcd.c lcd_init.c
  group lvgl/core
    ../LVGL8/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/draw
    ../LVGL8/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/font
    ../LVGL8/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/hal
    ../LVGL8/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/misc
    ../LVGL8/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/widgets
    ../LVGL8/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/extra
    ../LVGL8/lvgl/src/extra/: lv_extra.c
    ../LVGL8/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL8/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL8/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL8/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL8/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL8/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL8/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL8/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL8/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL8/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL8/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL8/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL8/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL8/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL8/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL8/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL8/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL8/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL8/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL8/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL8/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL8/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl/drive
    ../LVGL8/lvgl_drive/: lv_port_disp.c
software components: CMSIS:CORE 5.5.0
